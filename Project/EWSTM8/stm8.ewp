# IAR project stm8.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L051F3 STM8L051F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L05X_LD_VL
  ICCSTM8.CCIncludePath2: ..\..\SourceCode; ..\..\SourceCode\driver; ..\..\SourceCode\sky1311; ..\..\SourceCode\iso14443; ..\..\Libraries\STM8L15x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: sky1311t_reader.s19
  ILINK.IlinkOutputFile: sky1311t_reader.out
  ILINK.IlinkConfigDefines: CARDTYPE=-1
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group SourceCode
    ../../SourceCode/: cardoper.c main.c
  group SourceCode/driver
    ../../SourceCode/driver/: i2c.c key.c motor.c ring_buffer.c sky1311_drv.c stm8l15x_it.c system.c timer.c uart.c voltage.c
  group SourceCode/inc
    ../../SourceCode/driver/: i2c.h key.h motor.h ring_buffer.h system.h timer.h uart.h voltage.h
    ../../SourceCode/iso14443/: iso14443.h
    ../../SourceCode/: mcu.h typedef.h userdef.h
    ../../SourceCode/sky1311/: sky1311t.h sky1311t_reg.h
  group SourceCode/iso14443
    ../../SourceCode/iso14443/: iso14443a.c iso14443b.c mifare1.c
  group SourceCode/protocol
    ../../SourceCode/protocol/: x1000.c x1000.h
  group SourceCode/sky1311t
    ../../SourceCode/sky1311/: sky1311t.c
  group STM8L15x_StdPeriph_Driver/src
    ../../Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_exti.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_pwr.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim2.c stm8l15x_usart.c
